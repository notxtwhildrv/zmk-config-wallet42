## boards/shields/notxt12x5/Kconfig.defconfig
```kconfig
if SHIELD_NOTXT12X5

config ZMK_KEYBOARD_NAME
    default "notxt12x5"

config ZMK_USB
    default y
    
endif
```
